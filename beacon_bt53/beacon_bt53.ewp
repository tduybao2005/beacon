# IAR project beacon_bt53.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG22C112F352GM32 SiliconLaboratories EFR32BG22C112F352GM32
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: EFR32BG22C112F352GM32=1; SL_CODE_COMPONENT_SYSTEM=system; SL_APP_PROPERTIES=1; BOOTLOADER_APPLOADER=1; SL_CODE_COMPONENT_CLOCK_MANAGER=clock_manager; SL_COMPONENT_CATALOG_PRESENT=1; SL_CODE_COMPONENT_DEVICE_PERIPHERAL=device_peripheral; SL_CODE_COMPONENT_GPIO=gpio; SL_CODE_COMPONENT_HAL_COMMON=hal_common; SL_CODE_COMPONENT_HAL_GPIO=hal_gpio; SL_CODE_COMPONENT_INTERRUPT_MANAGER=interrupt_manager; CMSIS_NVIC_VIRTUAL=1; CMSIS_NVIC_VIRTUAL_HEADER_FILE="cmsis_nvic_virtual.h"; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; SL_CODE_COMPONENT_POWER_MANAGER=power_manager; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=0; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>; SL_CODE_COMPONENT_SE_MANAGER=se_manager; SL_CODE_COMPONENT_CORE=core; SL_RAIL_3_API=1; SL_CODE_COMPONENT_SLEEPTIMER=sleeptimer; SL_CODE_COMPONENT_SLI_CRYPTO=sli_crypto; SLI_RADIOAES_REQUIRES_MASKING=1; SL_CODE_COMPONENT_SLI_PROTOCOL_CRYPTO=sli_protocol_crypto; SL_CODE_COMPONENT_PSEC_OSAL=psec_osal
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; autogen; config; config\btconf; .; ..\..\..\silabs\simplicity_sdk\platform\Device\SiliconLabs\EFR32BG22\Include; ..\..\..\silabs\simplicity_sdk\app\common\util\app_assert; ..\..\..\silabs\simplicity_sdk\app\common\util\app_timer; ..\..\..\silabs\simplicity_sdk\app\common\util\app_timer\bm; ..\..\..\silabs\simplicity_sdk\protocol\bluetooth\inc; ..\..\..\silabs\simplicity_sdk\platform\common\inc; ..\..\..\silabs\simplicity_sdk\protocol\bluetooth\bgcommon\inc; ..\..\..\silabs\simplicity_sdk\protocol\bluetooth\bgstack\ll\inc; ..\..\..\silabs\simplicity_sdk\platform\bootloader; ..\..\..\silabs\simplicity_sdk\platform\bootloader\api; ..\..\..\silabs\simplicity_sdk\platform\bootloader\core\flash; ..\..\..\silabs\simplicity_sdk\platform\service\clock_manager\inc; ..\..\..\silabs\simplicity_sdk\platform\service\clock_manager\src; ..\..\..\silabs\simplicity_sdk\platform\CMSIS\Core\Include; ..\..\..\silabs\simplicity_sdk\platform\service\device_manager\inc; ..\..\..\silabs\simplicity_sdk\platform\service\device_init\inc; ..\..\..\silabs\simplicity_sdk\platform\emdrv\common\inc; ..\..\..\silabs\simplicity_sdk\platform\emlib\inc; ..\..\..\silabs\simplicity_sdk\app\bluetooth\common\gatt_service_device_information_override; ..\..\..\silabs\simplicity_sdk\platform\driver\gpio\inc; ..\..\..\silabs\simplicity_sdk\platform\peripheral\inc; ..\..\..\silabs\simplicity_sdk\app\bluetooth\common\in_place_ota_dfu; ..\..\..\silabs\simplicity_sdk\platform\service\interrupt_manager\inc; ..\..\..\silabs\simplicity_sdk\platform\service\interrupt_manager\src; ..\..\..\silabs\simplicity_sdk\platform\service\interrupt_manager\inc\arm; ..\..\..\silabs\simplicity_sdk\util\third_party\crypto_ip\libcryptosoc\include; ..\..\..\silabs\simplicity_sdk\util\third_party\crypto_ip\libcryptosoc\src; ..\..\..\silabs\simplicity_sdk\platform\security\sl_component\sl_mbedtls_support\config; ..\..\..\silabs\simplicity_sdk\platform\security\sl_component\sl_mbedtls_support\config\preset; ..\..\..\silabs\simplicity_sdk\platform\security\sl_component\sl_mbedtls_support\inc; ..\..\..\silabs\simplicity_sdk\util\third_party\mbedtls\include; ..\..\..\silabs\simplicity_sdk\util\third_party\mbedtls\library; ..\..\..\silabs\simplicity_sdk\platform\service\memory_manager\inc; ..\..\..\silabs\simplicity_sdk\platform\service\memory_manager\src; ..\..\..\silabs\simplicity_sdk\platform\service\memory_manager\profiler\inc; ..\..\..\silabs\simplicity_sdk\platform\service\mpu\inc; ..\..\..\silabs\simplicity_sdk\platform\emdrv\nvm3\inc; ..\..\..\silabs\simplicity_sdk\platform\emdrv\nvm3\config; ..\..\..\silabs\simplicity_sdk\platform\service\power_manager\inc; ..\..\..\silabs\simplicity_sdk\platform\security\sl_component\sl_psa_driver\inc; ..\..\..\silabs\simplicity_sdk\platform\radio\rail_lib\common; ..\..\..\silabs\simplicity_sdk\platform\radio\rail_lib\protocol\ble; ..\..\..\silabs\simplicity_sdk\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\silabs\simplicity_sdk\platform\radio\rail_lib\protocol\wmbus; ..\..\..\silabs\simplicity_sdk\platform\radio\rail_lib\protocol\zwave; ..\..\..\silabs\simplicity_sdk\platform\radio\rail_lib\chip\efr32\efr32xg2x; ..\..\..\silabs\simplicity_sdk\platform\radio\rail_lib\protocol\sidewalk; ..\..\..\silabs\simplicity_sdk\platform\radio\rail_lib\plugin\pa-conversions; ..\..\..\silabs\simplicity_sdk\platform\radio\rail_lib\plugin\pa-conversions\efr32xg22; ..\..\..\silabs\simplicity_sdk\platform\radio\rail_lib\plugin\rail_util_power_manager_init; ..\..\..\silabs\simplicity_sdk\platform\radio\rail_lib\plugin\rail_util_pti; ..\..\..\silabs\simplicity_sdk\platform\security\sl_component\se_manager\inc; ..\..\..\silabs\simplicity_sdk\platform\service\sl_main\inc; ..\..\..\silabs\simplicity_sdk\platform\service\sl_main\src; ..\..\..\silabs\simplicity_sdk\platform\service\sleeptimer\inc; ..\..\..\silabs\simplicity_sdk\platform\security\sl_component\sli_crypto\inc; ..\..\..\silabs\simplicity_sdk\platform\security\sl_component\sl_protocol_crypto\src; ..\..\..\silabs\simplicity_sdk\platform\security\sl_component\sli_psec_osal\inc; ..\..\..\silabs\simplicity_sdk\platform\service\udelay\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: beacon_bt53.s37
  ILINK.IlinkOutputFile: beacon_bt53.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: beacon_bt53.ipcf
  group Simplicity Configurator/image
    image/: readme_img0.png readme_img1.png readme_img2.png readme_img3.png readme_img4.png
  group Simplicity Configurator/simplicity_sdk_2025.6.3/protocol/bluetooth/api
    ../../../silabs/simplicity_sdk/protocol/bluetooth/api/: sl_bt.xapi
  group Simplicity Configurator/simplicity_sdk_2025.6.3/util/third_party/crypto_ip/libcryptosoc
    ../../../silabs/simplicity_sdk/util/third_party/crypto_ip/libcryptosoc/: LICENSE-Secure-IC.txt
